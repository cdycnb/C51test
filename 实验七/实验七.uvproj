# Keil uVision project 实验七.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 实验七 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: adc0809_driver.c adc0809_driver.h display.c display.h 实验七.c
