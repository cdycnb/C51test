# Keil uVision project 实验一仿真江科大.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 实验一仿真江科大 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main2.c
