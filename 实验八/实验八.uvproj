# Keil uVision project 实验八.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 实验八 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 实验八.c app_waveform.c app_waveform.h dac0832_driver.c dac0832_driver.h
